# IAR project stm32_01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ; modbus\ascii; modbus\functions; modbus\include; modbus\port; modbus\rtu; modbus\tcp; CMSIS\; FWLIB\inc\; USER\; DRIVER\inc; DRIVER\CMSIS\Include; DRIVER\inc; USER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_01.hex
  ILINK.IlinkOutputFile: stm32_01.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  group CMSIS/STARTUP
    CMSIS/STARTUP/: startup_stm32f10x_md.s
  group CMSIS/SYSTEM
    CMSIS/: system_stm32f10x.c
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group modbus
    modbus/: mb.c
  group modbus/ascii
    modbus/ascii/: mbascii.c mbascii.h
  group modbus/functions
    modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus/include
    modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/port
    modbus/port/: port.h portevent.c portserial.c porttimer.c
  group modbus/rtu
    modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group modbus/tcp
    modbus/tcp/: mbtcp.c mbtcp.h
  group USER
    USER/: main.c
