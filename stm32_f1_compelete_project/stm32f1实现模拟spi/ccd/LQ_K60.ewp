# IAR project LQ_K60.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; src\Includes; src\Libs; src\Source; src\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Users\Administrator\Desktop\ccd\src\Includes
  OBJCOPY.OOCOutputFile: LQ_K60.hex
  ILINK.IlinkOutputFile: LQ_K60.out
  ILINK.IlinkIcfFile: G:\学习办公\stm32\stm32工程\stm3201编写程序\ccd\src\Project_Setting\Linker_Files\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Includes
    src/Includes/: ADC.h CCD.h common.h DMA.h FTM.h GPIO.h GPIO_Cfg.h I2C.h Lptmr.h LQ12864.h PIT.h PLL.h UART.h vectors.h wdog.h
  group Libs
    src/Libs/: MK60N512VMD100.h
  group Project_Setting/Linker_Files
    src/Project_Setting/Linker_Files/: Pflash.icf
  group Project_Setting/Startup
    src/Project_Setting/Startup/: crt0.s start.c
  group Sourse
    src/Source/: ADC.c CCD.c common.c DMA.c FTM.c GPIO.c I2C.c Lptmr.c LQ12864.c PIT.c PLL.c UART.c vectors.c wdog.c
  group User
    src/User/: include.h main.c Serial_oscilloscope.c Serial_oscilloscope.h
